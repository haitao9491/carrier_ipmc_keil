# Keil uVision project ipmc.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2468 NXP
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: ipmc
  AfterMake: fromelf --bin !L --output .\output\bin\@H.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\app\main;..\app\driver\adc;..\app\driver\eeprom;..\app\driver\exi2c;..\app\driver\i2c;..\app\driver\uart;..\app\ipmi\include;..\ucos_ii\ports;..\ucos_ii\inc;..\app\driver;..\config;..\bsp\inc;..\app\driver\lpc2400def;..\app\driver\sensor
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group startup
    ../startup/: LPC2400.s
  group app
    ../app/main/: main.c boardinfo.c
  group ipmi
    ../app/ipmi/lib/: ipmi_comm.c ipmi_console.c ipmi_event.c ipmi_fru.c ipmi_led.c ipmi_sdr.c ipmi_sensor.c ipmi_wdt.c ipmi_device.c ipmi_cpld.c
  group driver
    ../app/driver/adc/: adc.c
    ../app/driver/eeprom/: eeprom.c
    ../app/driver/exi2c/: exi2c.c
    ../app/driver/i2c/: i2c.c
    ../app/driver/uart/: uart.c
    ../app/driver/sensor/: sensor_temp.c
  group ports
    ../ucos_ii/ports/: app_hooks.c os_cpu_c.c os_dbg.c os_cpu_a.asm
  group configs
    ../config/: app_cfg.h config.h
    ../ucos_ii/inc/: os_cfg.h
  group ucosii
    ../ucos_ii/source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group bsp
    ../bsp/src/: bsp.c bsp_gpio.c bsp_int.c bsp_os.c bsp_queue.c bsp_sys_ctrl.c bsp_uart.c target.c
